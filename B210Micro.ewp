# IAR project B210Micro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x8 ST STM32F100x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Boards; uCOS-II\Source; uCOS-II\Ports\arm-cortex-m3\Generic\IAR; uC-CPU\ARM-Cortex-M3\IAR; uC-CPU; uC-LIB; FWLib\library\inc; Boards\BSP; Interrupt
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B210Micro.hex
  ILINK.IlinkOutputFile: B210Micro.out
  ILINK.IlinkIcfFile: E:\MyProjects\B210Micro\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    Boards/: app.c app_vect_v5.c
  group BSP
    Boards/BSP/: bsp.c bsp_int.c bsp_periph.c
  group FWLib
    FWLib/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Interrupt
    Interrupt/: stm32f10x_it.c
  group uc/CPU
    uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    uC-CPU/: cpu_def.h
  group uc/OS-II/Port
    uCOS-II/Ports/arm-cortex-m3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uc/OS-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
